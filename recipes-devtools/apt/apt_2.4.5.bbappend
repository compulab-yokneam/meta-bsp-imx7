FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-mmap-include-stdint.h-for-uint16_t.patch"
