FILESEXTRAPATHS_append := "${THISDIR}/linux-compulab:"

SRC_URI_append = " \
	file://0001-cl-som-imx7-dts-phy-Provide-backward-compatibility.patch \
"
