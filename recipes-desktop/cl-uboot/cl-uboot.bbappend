DESCRIPTION = "CompuLab U-Boot Tool for imx7 SoC"

PACKAGE_ARCH = "${MACHINE_ARCH}"
COMPATIBLE_MACHINE = "cl-som-imx7"
