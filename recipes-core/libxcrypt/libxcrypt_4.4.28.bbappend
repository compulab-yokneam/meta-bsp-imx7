FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-build-replace-deprecated-perl-switch-statements.patch"
