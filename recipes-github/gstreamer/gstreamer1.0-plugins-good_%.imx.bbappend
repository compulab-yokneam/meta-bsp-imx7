# recipe: sources/meta-fsl-bsp-release/imx/meta-bsp/recipes-multimedia/gstreamer/gstreamer1.0-plugins-good_1.16.imx.bb
# Already fixed by NXP
#GST1.0-PLUGINS-GOOD_SRC = "gitsm://github.com/nxp-imx/gst-plugins-good.git;protocol=https"
