# recipe: sources/meta-fsl-bsp-release/imx/meta-bsp/recipes-multimedia/gstreamer/gstreamer1.0_1.16.imx.bb
# Already fixed by NXP
#GST1.0_SRC = "gitsm://github.com/nxp-imx/gstreamer.git;protocol=https"
