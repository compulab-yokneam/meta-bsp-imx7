# recipe: sources/meta-fsl-bsp-release/imx/meta-bsp/recipes-multimedia/gstreamer/gstreamer1.0-plugins-base_1.16.imx.bb
# Already fixed by NXP
#GST1.0-PLUGINS-BASE_SRC = "gitsm://github.com/nxp-imx/gst-plugins-base.git;protocol=https"
