# recipe: meta-fsl-bsp-release/imx/meta-bsp/recipes-kernel/linux/linux-imx-headers_4.19.35.bb 
# Already fixed by NXP
#KERNEL_SRC = "git://github.com/nxp-imx/linux-imx.git;protocol=https"
