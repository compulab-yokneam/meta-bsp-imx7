# recipe: meta-freescale/recipes-graphics/drm/libdrm_2.4.91.imx.bb 
IMX_LIBDRM_SRC = "git://github.com/nxp-imx/libdrm-imx.git;protocol=https;nobranch=1"
